# Autodesk Inventor assembly: Ensemb Pilote TP 32
## iProperties
Created: 2013-10
Part Number: Ensemb Pilote TP 32
Document SubType Name: Assembly
Designer: Bernard QUIVRIN
Author: Bernard QUIVRIN
